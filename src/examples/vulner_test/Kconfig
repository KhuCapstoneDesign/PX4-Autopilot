## src/examples/vulner_test/Kconfig
```kconfig
menuconfig EXAMPLES_VULNER_TEST
	bool "vulner_Test"
	default n
	---help---
		Enable support for vulner_test
```
